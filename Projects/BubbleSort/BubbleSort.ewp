# IAR project BubbleSort.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: inc; common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BubbleSort.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    common/: misc.c startup_stm32f401xx.s stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group Common/Inc
    common/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h misc.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_usart.h system_stm32f4xx.h
  group User
    src/: BubbleSort.s hw_init.c interrupt.c lab1.s main.c print.c pseudo_random.c
  group User/Inc
    inc/: hw_init.h interrupt.h main.h nucleoboard.h print.h pseudo_random.h
